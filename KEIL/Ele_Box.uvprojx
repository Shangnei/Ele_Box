# Keil uVision project Ele_Box.uvprojx, settings and files
target Ele_Box (6220000::V6.22::ARMCLANG)
  device: YTM32B1LE05 YTMicro
  pack: YTMicro.YTM32B1LE0_DFP.1.2.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) IROM2(0x10000000,0x800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Ele_Box +hex
  AfterMake: fromelf --bin --bincombined --output=Objects\@L.bin !L
  AfterMake: fromelf --m32 --m32combined --output=Objects\@L.srec !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: YTM32B1LE0,CPU_YTM32B1LE0,
  c include: ../board;../platform/drivers/src/clock/YTM32B1Lx;../platform/drivers/src/pins;../platform/drivers/src/dma;../platform/drivers/src/spi;../platform/drivers/src/ptmr;../platform/drivers/src/uart;../platform/drivers/inc;../platform/devices/common;../platform/devices;../platform/devices/YTM32B1LE0/include;../platform/devices/YTM32B1LE0/startup;../CMSIS/Core/Include;../rtos/osif;..\Hardware;..\app;../middleware/utility_print/printf;..\Hardware\U8g2;../platform/drivers/src/adc;../platform/drivers/src/i2c
  asm include: ../board;../platform/drivers/src/clock/YTM32B1Lx;../platform/drivers/src/pins;../platform/drivers/src/dma;../platform/drivers/src/spi;../platform/drivers/src/ptmr;../platform/drivers/src/uart;../platform/drivers/inc;../platform/devices/common;../platform/devices;../platform/devices/YTM32B1LE0/include;../platform/devices/YTM32B1LE0/startup;../CMSIS/Core/Include;../rtos/osif;..\Hardware;..\app;../middleware/utility_print/printf;../platform/drivers/src/adc;../platform/drivers/src/i2c
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ../board/yt_linker.scf
  link misc: --entry Reset_Handler --no_startup --diag_suppress=L6314W,L6221E,L6329W --keep=*(.isr_vector)
  group app
    ../app/: main.c
  group board
    ../board/: clock_config.c clock_config.h pin_mux.c pin_mux.h RamInit0.S RamInit1.c RamInit2.c startup.S vector.S vector_table_copy.c interrupt_config.c interrupt_config.h dma_config.c dma_config.h spi_config.c spi_config.h i2c_config.c i2c_config.h ptmr_config.c ptmr_config.h adc_config.c adc_config.h uart_config.c uart_config.h lin_config.c lin_config.h utility_print_config.h utility_print_config.c sdk_project_config.h
  group platform
    ../platform/drivers/src/clock/YTM32B1Lx/: cfmu_hw_access.h clock_YTM32B1Lx.c clock_YTM32B1Lx.h cmu_hw_access.h ipc_hw_access.h scu_hw_access.h
    ../platform/drivers/inc/: clock.h clock_manager.h pins_driver.h interrupt_manager.h dma_driver.h spi_master_driver.h spi_slave_driver.h spi_shared_function.h i2c_driver.h ptmr_driver.h adc_driver.h lin_driver.h uart_driver.h
    ../platform/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
    ../platform/devices/common/: core_common.h
    ../platform/devices/: callbacks.h devassert.h device_registers.h floats.h status.h
    ../platform/devices/YTM32B1LE0/include/: YTM32B1LE0.h YTM32B1LE0_features.h
    ../platform/devices/YTM32B1LE0/startup/: system_YTM32B1LE0.c system_YTM32B1LE0.h
    ../platform/drivers/src/interrupt/: interrupt_manager.c
    ../platform/drivers/src/dma/: dma_driver.c dma_hw_access.c dma_hw_access.h dma_irq.c dma_irq.h
    ../platform/drivers/src/spi/: spi_hw_access.c spi_hw_access.h spi_irq.c spi_master_driver.c spi_shared_function.c spi_slave_driver.c
    ../platform/drivers/src/i2c/: i2c_driver.c i2c_hw_access.h i2c_irq.c i2c_irq.h
    ../platform/drivers/src/ptmr/: ptmr_driver.c ptmr_hw_access.h
    ../platform/drivers/src/adc/: adc_driver.c adc_hw_access.h
    ../platform/drivers/src/uart/: lin_uart_driver.c lin_uart_driver.h uart_driver.c uart_hw_access.c uart_hw_access.h uart_irq.c uart_irq.h
    ../platform/drivers/src/lin/: lin_common.c lin_driver.c lin_irq.c
  group CMSIS
    ../CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group rtos
    ../rtos/osif/: osif.h osif_baremetal.c
  group middleware
    ../middleware/utility_print/printf/: printf.c printf.h
  group Hardware
    ../Hardware/U8g2/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
    ../Hardware/: u8g2_d.c u8g2_d.h Joystick.c Joystick.h Ina226.c Ina226.h Autofox_INA226.c Autofox_INA226_c.h
